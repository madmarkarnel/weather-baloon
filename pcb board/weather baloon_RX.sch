File: pcb board/weather baloon_RX.sch (EAGLE design)
At the start: 12 parts

Commit message: updated frame of schematic
Other:
- moved on the sheet: H1, H2, H3, H4, I2C, RTC, RX3, S1, U$6
