File: pcb board/weather baloon_tx.sch (EAGLE design)
At the start: 12 parts

Commit message: updated frame of schematic
Other:
- moved on the sheet: H1, H2, H3, H4, S1, SV3, U$6
